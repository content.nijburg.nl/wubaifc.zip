Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 0f58afc0-bcb1-4fe6-a661-38b5a4e2447c, NumberOfSaves: 33]
File name: Project Number
Time: 2024-01-24T13:16:36+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_2052117_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_wall grill wuba return LT_sacs:WUBAO, NLRS_57_AIR_UN_wall grill wuba return LT_sacs:WUBAO:2052117
In: Default
Type - Description: Solid Air wall diffuser WUBA (return); PredefinedType: DIFFUSER; Material: NLRS_57_anodised aluminium_gen_sacs
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_wall grill wuba return LT_sacs; SACS_Base_Index: 1
Type - Constraints - Default Elevation: 0 mm
Type - General - FactorTable: WUBA_Factors (return); LookupTable: WUBA
Type - Identity Data - Assembly Code: 57.0; Description: Solid Air wall diffuser WUBA (return); Manufacturer: Solid Air Climate Systems; Model: Wall diffuser; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 08-08-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.02; NLRS_C_niveau ontwikkeling: LOD 400; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: WUBAO; URL: https://solid-air.nl/producten/solid-air-wandroosters-wuaa-wuba-wuca/
Type - Materials and Finishes - SACS_Material_Frame: Extruded Aluminium; SACS_Material_VCD: Extruded Aluminium
Type - Mechanical - Flow - Max Flow: 0 dm3/s; Min Flow: 0 dm3/s
Type - Visibility - SACS_Show_Symbol: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Systems
Classification: 57.0 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: WUBAO; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_wall grill wuba return LT_sacs; Family and Type: NLRS_57_AIR_UN_wall grill wuba return LT_sacs: WUBAO; Type: WUBAO; Type Id: 2052092
Model Properties - Color Option (1-3): 1; SACS_Color_Ral: yes; SACS_Damper_Open_%: 100; SACS_Option_1: Flange 32mm, fixed core; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 0.612722 m2; Maximum size: 1225x425; Minimum size: 225x85; NLRS_M_c01_breedte: 625 mm; NLRS_M_c01_hoogte: 225 mm; SACS_Height: 225 mm; SACS_Width: 625 mm; Size: 625x225; Volume: 0.000782083 m3
Identity Data - Mark: 8410; NLRS_C_description: Solid Air wall diffuser WUBA (return); NLRS_C_materiaal_kleur: Anodised aluminium (standard); NLRS_C_model: WUBAOO 625x225; SACS_Article_Code: 8301000168; SACS_Gross_Cost: 92; SACS_Price_Date: 15-06-2022
Materials and Finishes - SACS_Color: Anodised aluminium (standard); SACS_Face_Color: NLRS_57_anodised aluminium_gen_sacs
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 15 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 0 dm3/s; NLRS_M_c01_debiet: 0 dm3/s; SACS_Lp_dBA: 0; SACS_Nominal_Max_Flow: 800 dm3/s; SACS_Nominal_Min_Flow: 200 dm3/s
Phasing - Phase Created: New Construction
Visibility - SACS_Show_Arrows: yes; SACS_Warning_Disabled: no
